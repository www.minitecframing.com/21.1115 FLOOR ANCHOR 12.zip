# Autodesk Inventor assembly: 21.1115 FLOOR ANCHOR 12
## iProperties
Created: 2007-04
Part Number: 21.1115 FLOOR ANCHOR 12
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
